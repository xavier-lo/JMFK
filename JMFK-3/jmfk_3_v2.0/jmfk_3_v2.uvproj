# Keil uVision project jmfk_3_v2.uvproj, settings and files
target Target 1 (MCS-51)
  device: MC95FG0128 ABOV Semiconductor
  cpu: IRAM(0x00 - 0xFF) XRAM(0x0000-0x1FFF) IROM(0-0x1FFFF) CLOCK(12000000) MOD517DP
  output: jmfk_3_v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC_INIT.C STC_ISR.C STC_USER.C operate_card.c time_sd2200.c SHJY_IIC.C stc_eeprom.c
